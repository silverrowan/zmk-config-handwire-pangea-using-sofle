## config/boards/shields/pangeaHandwire/Kconfig.defconfig
```kconfig
if SHIELD_PANGEAHANDWIRE

config ZMK_KEYBOARD_NAME
    default "pangeaHandwire"

endif
```
